# Keil uVision project C8T6.uvprojx, settings and files
target WY (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: t1 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\UART;..\HARDWARE\EXTI;..\HARDWARE\OLED;..\HARDWARE\TIMER;..\HARDWARE\PWM;..\HARDWARE\CAPTURE;..\HARDWARE\TPAD;..\HARDWARE\TFTLCD;..\HARDWARE\ADC;..\HARDWARE\GPIO;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\ULTRASONIC;..\HARDWARE\OV7725;..\HARDWARE\OPENMV;..\HARDWARE\HOST;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\ENCODE;..\HARDWARE\FLASH
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c use.c pidctrl.c stm32f10x_it.c system_stm32f10x.c wy_menu.c control.c
  group USER_H
    ./: main.h use.h pidctrl.h stm32f10x.h stm32f10x_conf.h stm32f10x_it.h system_stm32f10x.h wy_headfile.h wy_menu.h control.h
  group HARDWARE
    ../HARDWARE/GPIO/: wy_gpio.c
    ../HARDWARE/BEEP/: wy_beep.c
    ../HARDWARE/LED/: wy_led.c
    ../HARDWARE/KEY/: wy_key.c
    ../HARDWARE/UART/: wy_uart.c
    ../HARDWARE/EXTI/: wy_exti.c
    ../HARDWARE/OLED/: wy_oled.c wy_font.c
    ../HARDWARE/TIMER/: wy_timer.c
    ../HARDWARE/PWM/: wy_pwm.c
    ../HARDWARE/ENCODE/: wy_encode.c
    ../HARDWARE/CAPTURE/: wy_capture.c
    ../HARDWARE/TPAD/: wy_tpad.c
    ../HARDWARE/TFTLCD/: wy_tftlcd.c
    ../HARDWARE/ADC/: wy_adc.c
    ../HARDWARE/MPU6050/: wy_mpu6050.c wy_mpuiic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/IIC/: wy_iic.c
    ../HARDWARE/ULTRASONIC/: wy_ultrasonic.c
    ../HARDWARE/OV7725/: wy_ov7725.c sccb.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/OPENMV/: wy_openmv.c
    ../HARDWARE/HOST/: wy_host.c
    ../HARDWARE/FLASH/: wy_flash.c
  group HARDWARE_H
    ../HARDWARE/GPIO/: wy_gpio.h
    ../HARDWARE/BEEP/: wy_beep.h
    ../HARDWARE/LED/: wy_led.h
    ../HARDWARE/KEY/: wy_key.h
    ../HARDWARE/UART/: wy_uart.h
    ../HARDWARE/EXTI/: wy_exti.h
    ../HARDWARE/OLED/: wy_oled.h wy_font.h
    ../HARDWARE/TIMER/: wy_timer.h
    ../HARDWARE/PWM/: wy_pwm.h
    ../HARDWARE/ENCODE/: wy_encode.h
    ../HARDWARE/CAPTURE/: wy_capture.h
    ../HARDWARE/TPAD/: wy_tpad.h
    ../HARDWARE/TFTLCD/: wy_tftlcd.h
    ../HARDWARE/ADC/: wy_adc.h
    ../HARDWARE/MPU6050/: wy_mpu6050.h wy_mpuiic.h
    ../HARDWARE/MPU6050/eMPL/: dmpKey.h dmpmap.h inv_mpu_dmp_motion_driver.h inv_mpu.h
    ../HARDWARE/ULTRASONIC/: wy_ultrasonic.h
    ../HARDWARE/OV7725/: wy_ov7725.h ov7725config.h sccb.h
    ../HARDWARE/HOST/: wy_host.h
    ../HARDWARE/OPENMV/: wy_openmv.h
    ../HARDWARE/24CXX/: 24cxx.h
    ../HARDWARE/FLASH/: wy_flash.h
    ../HARDWARE/IIC/: wy_iic.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group SYSTEM_H
    ../SYSTEM/delay/: delay.h
    ../SYSTEM/sys/: sys.h
    ../SYSTEM/usart/: usart.h
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FWLIB_H
    ../STM32F10x_FWLib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
